Commit message: Fix joint type for base_link_Revolute-2 in robot.urdf and add robot.xml model

File: urdf/robot.urdf (robot description, URDF)
Before this commit: robot robot, 3 links, 2 joints
Joints:
- joint base_link_Revolute-2: type continuous -> revolute
